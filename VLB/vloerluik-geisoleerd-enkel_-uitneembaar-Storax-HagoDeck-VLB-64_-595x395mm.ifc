Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 68ab1c90-5c75-42b8-8988-5965c2779406.ifc
Time: 2026-09-11T15:35:18
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - HagoDeck VLB 64, 595x395mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 2,5 m²·k/w
Pset_Data - WUID: AgAAAD7DyLoFAAAAnIgAAAV2SgAAJVQBAFJfAQDxgwAAg54AAAIA6gcBAQAAAAEAAADlBwEBAAAABAAAAIkNAgAFBv4AAM6LAQC7cwAAhw0CAIgNAgACACoAAQEAAAACAAAADQABAQAAAAMAAAARSgEABaULAABkMAAAxqcAAKOtAAAwSAEAAAC4DQIABfW2AABkMAAAxqcAAKOtAAC3DQIAAADygQAABWa5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAD7DyLoFAAAAnIgAAAV2SgAAJVQBAFJfAQDxgwAAg54AAAIA6gcBAQAAAAEAAADlBwEBAAAABAAAAIkNAgAFBv4AAM6LAQC7cwAAhw0CAIgNAgACACoAAQEAAAACAAAADQABAQAAAAMAAAARSgEABaULAABkMAAAxqcAAKOtAAAwSAEAAAC4DQIABfW2AABkMAAAxqcAAKOtAAC3DQIAAADygQAABWa5AABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 43.31.10; plaatdikte: 25 mm; isolatiedikte: 90 mm; dagmaatlengte: 595 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 2,5 m²·k/w; gewicht per st: 5 kg/st; type: VLB 64; serie: HagoDeck; afsluitbaar: False; hoogte: 115 mm; merk: Storax; dagmaatbreedte: 395 mm; omranding: staal; luik: luik element sandwichplaat (geïsoleerd) Storax - onderdelen
