Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: e8691027-baa0-434d-baec-ab3a534757d2.ifc
Time: 2026-09-11T15:37:36
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - HagoDeck VLB 65, 595x495mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 2,5 m²·k/w
Pset_Data - WUID: AgAAAD58RLoFAAAAnIgAAAV2SgAAJVQBAFJfAQDxgwAAPBIAAAIA6gcBAQAAAAEAAADlBwEBAAAABAAAAIkNAgAFBv4AAM6LAQC7cwAAhw0CAIgNAgACACoAAQEAAAACAAAADQABAQAAAAMAAAARSgEABaULAABkMAAAxqcAAKOtAAAwSAEAAAC4DQIABfW2AABkMAAAxqcAAKOtAAC3DQIAAADygQAABWa5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAD58RLoFAAAAnIgAAAV2SgAAJVQBAFJfAQDxgwAAPBIAAAIA6gcBAQAAAAEAAADlBwEBAAAABAAAAIkNAgAFBv4AAM6LAQC7cwAAhw0CAIgNAgACACoAAQEAAAACAAAADQABAQAAAAMAAAARSgEABaULAABkMAAAxqcAAKOtAAAwSAEAAAC4DQIABfW2AABkMAAAxqcAAKOtAAC3DQIAAADygQAABWa5AABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 43.31.10; plaatdikte: 25 mm; isolatiedikte: 90 mm; dagmaatlengte: 595 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 2,5 m²·k/w; gewicht per st: 6 kg/st; type: VLB 65; serie: HagoDeck; afsluitbaar: False; hoogte: 115 mm; merk: Storax; dagmaatbreedte: 495 mm; omranding: staal; luik: luik element sandwichplaat (geïsoleerd) Storax - onderdelen
